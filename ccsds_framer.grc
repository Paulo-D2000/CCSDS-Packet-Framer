options:
  parameters:
    author: Paulo Dutra - PU4THZ
    description: Bytes -> RS(223,255) -> Scrambler(CCSDS) -> Syncword(CCSDS) -> Fec(2,7) -> bytes
    generate_options: hb
    id: ccsds_framer
    output_language: python
    title: CCSDS Concatenated Packet Framer
  states: {}

blocks:
- name: fecpat
  id: variable
  parameters:
    value: '{''1/2'':''11'', ''2/3'':''1101'',  ''3/4'':''110110'',  ''5/6'':''1101100110'',  ''7/8'':''11010101100110''}'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: byte
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: byte
  states: {}
- name: blocks_not_xx_0
  id: blocks_not_xx
  parameters:
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: ''
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: 223-padding
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: len(syncword_str)
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_1_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: padding
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[int(i) for i in syncword_str]'
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0]*padding'
  states: {state: disabled}
- name: digital_additive_scrambler_bb_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: '7'
    mask: '0xa9'
    reset_tag_key: '"packet_len"'
    seed: '0xff'
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    input_reflected: 'False'
    poly: '0x4C11DB7'
    result_reflected: 'False'
  states: {}
- name: fec_encode_ccsds_27_bb_0
  id: fec_encode_ccsds_27_bb
  parameters: {}
  states: {}
- name: fec_puncture_xx_0
  id: fec_puncture_xx
  parameters:
    delay: '0'
    puncpat: int(fecpat[fec_rate],2)
    puncsize: len(fecpat[fec_rate])
    type: byte
  states: {}
- name: fec_puncture_xx_0_0
  id: fec_puncture_xx
  parameters:
    delay: '0'
    puncpat: int(fecpat[fec_rate],2)
    puncsize: len(fecpat[fec_rate])
    type: byte
  states: {}
- name: fec_rate
  id: parameter
  parameters:
    label: FEC Rate
    type: str
    value: '"1/2"'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: padding
  id: parameter
  parameters:
    label: Padding Bytes
    type: intx
    value: '0'
  states: {}
- name: pdu_pdu_to_tagged_stream_1_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: satellites_encode_rs_ccsds_0_0
  id: satellites_encode_rs_ccsds
  parameters:
    basis: 'True'
    interleave: '1'
  states: {state: disabled}
- name: syncword_str
  id: parameter
  parameters:
    label: Syncword
    type: str
    value: '"00011010110011111111110000011101"'
  states: {}

connections:
- [blocks_deinterleave_0, '0', blocks_not_xx_0, '0']
- [blocks_deinterleave_0, '1', fec_puncture_xx_0_0, '0']
- [blocks_interleave_0, '0', blocks_repack_bits_bb_1_0, '0']
- [blocks_not_xx_0, '0', fec_puncture_xx_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_additive_scrambler_bb_0, '0']
- [blocks_repack_bits_bb_1_0, '0', pad_sink_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', fec_encode_ccsds_27_bb_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_1, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_1_0, '0', blocks_tagged_stream_mux_0_0, '1']
- [blocks_tagged_stream_mux_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [blocks_tagged_stream_mux_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_1, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_stream_to_tagged_stream_1_0, '0']
- [digital_additive_scrambler_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc_append_0, out, pdu_pdu_to_tagged_stream_1_0, pdus]
- [fec_encode_ccsds_27_bb_0, '0', blocks_deinterleave_0, '0']
- [fec_puncture_xx_0, '0', blocks_interleave_0, '1']
- [fec_puncture_xx_0_0, '0', blocks_interleave_0, '0']
- [pad_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [pdu_pdu_to_tagged_stream_1_0, '0', blocks_repack_bits_bb_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc_append_0, in]
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_encode_rs_ccsds_0_0, in]
- [satellites_encode_rs_ccsds_0_0, out, pdu_pdu_to_tagged_stream_1_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
