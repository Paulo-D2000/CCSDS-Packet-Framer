options:
  parameters:
    author: Paulo Dutra - PU4THZ
    copyright: Paulo Dutra - PU4THZ
    description: Example usage of the CCSDS Concatenated Packet Framer (CRC32) block
    generate_options: qt_gui
    id: example_crc32
    output_language: python
    title: CCSDS Packet Framer Example CRC32
  states: {}

blocks:
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: fec_rate
  id: variable
  parameters:
    value: '"1/2"'
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: padding_bytes
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_char_to_float_0_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ccsds_framer_crc32_1
  id: ccsds_framer_crc32
  parameters:
    fec_rate: '"1/2"'
    padding: '0'
    syncword_str: '"00011010110011111111110000011101"'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    input_reflected: 'False'
    poly: '0x4C11DB7'
    result_reflected: 'False'
  states: {}
- name: pdu_pdu_to_tagged_stream_1_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: satellites_ccsds_concatenated_deframer_0_0
  id: satellites_ccsds_concatenated_deframer
  parameters:
    convolutional: '"CCSDS"'
    frame_size: '223'
    precoding: None
    rs_basis: '"dual"'
    rs_interleaving: '1'
    scrambler: '"CCSDS"'
    threshold: '0'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: tx_crc32
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: pdu_crc32
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: tx_crc32
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: pdu_crc32
  states: {}

connections:
- [analog_random_source_x_0, '0', ccsds_framer_crc32_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_char_to_float_0_1_0_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_char_to_float_0_1_0_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_real_0, '0', satellites_ccsds_concatenated_deframer_0_0, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_0_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_0_1_0_0_0, '0']
- [blocks_throttle2_0, '0', blocks_complex_to_real_0, '0']
- [ccsds_framer_crc32_1, '0', blocks_repack_bits_bb_0, '0']
- [channels_channel_model_0_0, '0', blocks_throttle2_0, '0']
- [digital_crc_check_0, ok, virtual_sink_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_1_0_0, '0', blocks_char_to_float_0_1_0_0, '0']
- [satellites_ccsds_concatenated_deframer_0_0, out, digital_crc_check_0, in]
- [virtual_source_0_1, '0', channels_channel_model_0_0, '0']
- [virtual_source_1_0_0, '0', pdu_pdu_to_tagged_stream_1_0_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
